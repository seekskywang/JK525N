# Keil uVision project BH-F429.uvprojx, settings and files
target 工程模板 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\..\Output\update.bin ..\..\Output\Template.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_USB_OTG_FS
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\HARDWARE;..\..\User\lcd;..\..\FATFS;..\..\User\flash;..\..\HARDWARE\font;..\..\User\APP;..\..\User\RTC;..\..\FILESYS;..\..\User\beep;..\..\User\usb;..\..\USBD_FS_HID;..\..\USBD_FS_Lib\USBD_inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\User\FATFS;..\..\User\sdio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c pbdata.c user.c test.c
  group DOC
    ../../: 必读说明.txt
  group HARDWARE
    ../../HARDWARE/: 4094.C AD7706.C GPIO.C keyboard.c cpld.c flash_eerom.c
    ../../HARDWARE/lcd/: bsp_lcd.c
    ../../HARDWARE/font/: fonts.c
    ../../HARDWARE/flash/: bsp_spi_flash.c
    ../../HARDWARE/sdram/: bsp_sdram.c
    ../../HARDWARE/tim/: bsp_basic_tim.c
    ../../HARDWARE/usart/: bsp_debug_usart.c
    ../../HARDWARE/tim_pwm/: bsp_general_tim.c
    ../../HARDWARE/systick/: bsp_SysTick.c
    ../../HARDWARE/adc/: bsp_adc.c
    ../../User/RTC/: bsp_rtc.c
    ../../User/: bsp_exti.c flash_if.c
    ../../HARDWARE/touch/: touch.c
    ../../HARDWARE/ch376/: ch376.c
    ../../User/beep/: bsp_beep.c
    ../../User/sdio/: bsp_sdio_sd.c
  group FATFS
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: cc936.c
  group ch376
    ../../FILESYS/: FILESYS.c
  group USBD/FS/Lib
    ../../USBD_FS_Lib/USBD-src/: usb_core.c usb_dcd.c usb_dcd_int.c usbd_core.c usbd_ioreq.c usbd_req.c
  group USBD/FS/HID
    ../../USBD_FS_HID/: usb_bsp.c usbd_desc.c usbd_hid_core.c usbd_usr.c
